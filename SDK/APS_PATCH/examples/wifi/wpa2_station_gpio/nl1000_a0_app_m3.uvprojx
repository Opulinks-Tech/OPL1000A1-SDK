# Keil uVision project nl1000_a0_app_m3.uvprojx, settings and files
target NL1000_APS_App (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: nl1000_a0_app_m3 +hex
  AfterMake: .\nl1000_a0_app_m3.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __noTI_C2654MOND__ __NL1000_A0__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __NO_EMBEDDED_ASM
  c misc: --preinclude=sys_common.h
  c include: ..\..\..\..\APS\FreeRtos\Source\include;..\..\..\..\APS\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\..\..\APS\driver\CMSIS\Include;..\..\..\..\APS\driver\CMSIS\Device\nl1000\Include;..\..\..\..\APS\driver\chip;..\..\..\..\APS\driver\chip\securityipdriver;..\..\..\..\APS\driver\chip\hal_tick;..\..\..\..\APS\driver\chip\hal_system;..\..\..\..\APS\driver\chip\hal_patch;..\..\..\..\APS\driver\chip\hal_uart;..\..\..\..\APS\driver\chip\hal_spi;..\..\..\..\APS\driver\chip\hal_vic;..\..\..\..\APS\driver\chip\hal_dbg_uart;..\..\..\..\APS\driver\chip\hal_wdt;..\..\..\..\APS\driver\chip\hal_dma;..\..\..\..\APS\driver\chip\hal_tmr;..\..\..\..\APS\driver\chip\hal_pwm;..\..\..\..\APS\driver\chip\hal_i2c;..\..\..\..\APS\project\nl1000\tasks;..\..\..\..\APS\project\nl1000\tasks\wifi_mac;..\..\..\..\APS\project\nl1000\include;..\..\..\..\APS\project\common;..\..\..\..\APS\middleware\netlink\cli;..\..\..\..\APS\middleware\netlink\msg;..\..\..\..\APS\middleware\netlink\data_flow;..\..\..\..\APS\middleware\netlink\wifi_controller_layer;..\..\..\..\APS\middleware\netlink\ble_controller_layer\inc;..\..\..\..\APS\middleware\netlink\le_stack;..\..\..\..\APS\middleware\netlink\at;..\..\..\..\APS\middleware\netlink\iperf\inc;..\..\..\..\APS\project\le_app;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\common;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eap_common;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eap_peer;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_supp;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_auth;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\radius;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\crypto;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\l2_packet;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\ap;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\wps;..\..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant\dbus;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\;..\..\..\..\APS\middleware\third_party\tinycrypt\include;..\..\..\..\APS\middleware\third_party\mbedtls\include;..\..\..\..\APS\project\nl1000\boot_sequence;..\..\..\..\APS\project\nl1000\startup;..\..\..\project\nl1000\include;..\..\..\middleware\netlink\wifi_controller_layer;..\wpa2_station;..\..\..\driver\chip\hal_pinmux;..\..\..\driver\chip\hal_vic
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  scatter file: .\nl1000_a0_app_m3.sct
  link misc: --datacompressor off
  group source
    ./: main_patch.c wpa2_station_app.c
  group object
    ../../../../APS/project/nl1000/object/: symdefs.o
    ../../../../APS/project/nl1000/Output/Objects/: nl1000_a0_patch_at_m3.lib nl1000_a0_sdk_at_m3.lib
  group PinMux
    ../../../driver/chip/hal_pinmux/: Hal_pinmux_api.c Hal_pinmux_common.c Hal_pinmux_gpio.c Hal_pinmux_uart.c
    ./: OPL1000_pin_mux_define.c
