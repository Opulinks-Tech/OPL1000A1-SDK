# Keil uVision project opl1000_boot_agent_m3.uvprojx, settings and files
target OPL1000_APS_Boot_Agent (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: opl1000_boot_agent_m3 +hex
  AfterMake: .\opl1000_boot_agent_m3.bat
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__
  c misc: --preinclude=sys_common.h
  c include: ..\..\..\APS\FreeRtos\Source\include;..\..\..\APS\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\..\APS\driver\CMSIS\Include;..\..\..\APS\driver\CMSIS\Device\opl1000\Include;..\..\..\APS\driver\chip;..\..\..\APS\driver\chip\opl1000\securityipdriver;..\..\..\APS\driver\chip\opl1000\hal_auxadc;..\..\..\APS\driver\chip\opl1000\hal_system;..\..\..\APS\driver\chip\opl1000\hal_patch;..\..\..\APS\driver\chip\opl1000\hal_uart;..\..\..\APS\driver\chip\opl1000\hal_spi;..\..\..\APS\driver\chip\opl1000\hal_vic;..\..\..\APS\driver\chip\opl1000\hal_dbg_uart;..\..\..\APS\driver\chip\opl1000\hal_wdt;..\..\..\APS\driver\chip\opl1000\hal_dma;..\..\..\APS\driver\chip\opl1000\hal_tmr;..\..\..\APS\driver\chip\opl1000\hal_tick;..\..\..\APS\driver\chip\opl1000\hal_pwm;..\..\..\APS\driver\chip\opl1000\hal_i2c;..\..\..\APS\project\opl1000\include;..\..\..\APS\project\common;..\..\..\APS\middleware\netlink;..\..\..\APS\middleware\netlink\cli;..\..\..\APS\middleware\netlink\msg;..\..\..\APS\middleware\netlink\data_flow;..\..\..\APS\middleware\netlink\wifi_controller_layer;..\..\..\APS\middleware\netlink\wifi_controller_layer\rom_if;..\..\..\APS\middleware\netlink\ble_controller_layer\inc;..\..\..\APS\middleware\netlink\le_stack;..\..\..\APS\middleware\netlink\at;..\..\..\APS\middleware\netlink\iperf\inc;..\..\..\APS\middleware\netlink\controller_task;..\..\..\APS\middleware\netlink\ps_task;..\..\..\APS\middleware\netlink\diag_task;..\..\..\APS\middleware\netlink\wifi_mac;..\..\..\APS\middleware\netlink\mw_fim;..\..\..\APS\apps\le_app\pts_app;..\..\..\APS\apps\le_app\mtc_app;..\..\..\APS\apps\le_app\cmd_app;..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\common;..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eap_common;..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eap_peer;..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_supp;..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_auth;..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\radius;..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\crypto;..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\l2_packet;..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\ap;..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\src\wps;..\..\..\APS\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant\dbus;..\..\..\APS\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\APS\middleware\third_party\lwip-2.0.3\;..\..\..\APS\middleware\third_party\tinycrypt\include;..\..\..\APS\middleware\third_party\mbedtls\include;..\..\..\APS\project\opl1000\boot_sequence;..\..\..\APS\project\opl1000\startup;..\..\middleware\netlink\mw_ota;..\..\driver\chip\opl1000\hal_spi
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  scatter file: .\opl1000_boot_agent_m3.sct
  link misc: --datacompressor off --diag_suppress=L6305
  group source
    ./: main_patch.c
    ../../middleware/netlink/mw_ota/: mw_ota.c mw_ota_boot.c
    ../../driver/chip/opl1000/hal_spi/: hal_flash_patch.c
  group object
    ../../../APS/targets/opl1000/object/: symdefs.o
