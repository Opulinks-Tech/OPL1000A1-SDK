# Keil uVision project nl1000_a0_sdk_m3.uvprojx, settings and files
target NL1000_APS_SDK_AT (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: nl1000_a0_sdk_at_m3 +hex (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __noTI_C2654MOND__ __NL1000_A0__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __NO_EMBEDDED_ASM __WIFI_AUTO_CONNECT__
  c misc: --preinclude=sys_common.h
  c include: ..\..\FreeRtos\Source\include;..\..\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\driver\CMSIS\Include;..\..\driver\CMSIS\Device\nl1000\Include;..\..\driver\chip;..\..\driver\chip\securityipdriver;..\..\driver\chip\hal_tick;..\..\driver\chip\hal_system;..\..\driver\chip\hal_patch;..\..\driver\chip\hal_uart;..\..\driver\chip\hal_spi;..\..\driver\chip\hal_vic;..\..\driver\chip\hal_dbg_uart;..\..\driver\chip\hal_wdt;..\..\driver\chip\hal_dma;..\..\driver\chip\hal_tmr;..\..\driver\chip\hal_pwm;..\..\driver\chip\hal_i2c;.\tasks;.\tasks\wifi_mac;.\include;..\common;..\..\middleware\netlink\cli;..\..\middleware\netlink\msg;..\..\middleware\netlink\data_flow;..\..\middleware\netlink\wifi_controller_layer;..\..\middleware\netlink\ble_controller_layer\inc;..\..\middleware\netlink\le_stack;..\..\middleware\netlink\at;..\..\middleware\netlink\iperf\inc;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\common;..\..\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eap_common;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eap_peer;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_supp;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_auth;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\radius;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\crypto;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\l2_packet;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\ap;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\wps;..\..\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant\dbus;..\..\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\middleware\third_party\lwip-2.0.3\lwip\src\include\lwip;..\..\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\middleware\third_party\lwip-2.0.3\;..\..\middleware\third_party\tinycrypt\include;..\..\middleware\third_party\mbedtls\include;.\boot_sequence;.\startup;..\..\..\APS_PATCH\middleware\netlink\at\patch;..\..\middleware\third_party\wpa_supplicant-0.7.3\patch;..\..\..\APS_PATCH\driver\chip\securityipdriver;..\..\..\APS_PATCH\project\nl1000\tasks\wifi_mac;..\..\..\APS_PATCH\project\nl1000\include;..\..\..\APS_PATCH\middleware\netlink\wifi_controller_layer;..\..\..\APS_PATCH\middleware\netlink\data_flow;..\..\..\APS_PATCH\middleware\netlink\ps_task;..\..\..\APS_PATCH\driver\chip\hal_auxadc;..\..\..\APS_PATCH\driver\chip\hal_dbg_uart;..\..\..\APS_PATCH\driver\chip\hal_dma;..\..\..\APS_PATCH\driver\chip\hal_i2c;..\..\..\APS_PATCH\driver\chip\hal_pwm;..\..\..\APS_PATCH\driver\chip\hal_spi;..\..\..\APS_PATCH\driver\chip\hal_system;..\..\..\APS_PATCH\driver\chip\hal_tmr;..\..\..\APS_PATCH\driver\chip\hal_uart;..\..\..\APS_PATCH\driver\chip\hal_vic;..\..\..\APS_PATCH\driver\chip\hal_wdt;..\..\..\APS_PATCH\driver\chip;..\..\..\APS_PATCH\middleware\netlink\le_stack\patch;..\..\..\APS_PATCH\middleware\netlink\le_stack\pts_app;..\..\..\APS_PATCH\middleware\netlink\le_stack\cmd_app;..\..\..\APS_PATCH\project\nl1000\tasks;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\common;..\..\..\APS_PATCH\middleware\netlink\at\patch;..\..\..\APS_PATCH\middleware\netlink\mw_fim;..\..\..\APS_PATCH\middleware\netlink\mw_ota;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\APS_PATCH\FreeRtos;..\..\..\APS_PATCH\FreeRtos\Source\include;..\..\..\APS_PATCH\middleware\netlink\msg;..\..\..\APS_PATCH\middleware\netlink\ble_controller_layer\patch
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  group startup
    ../../../APS_PATCH/project/nl1000/startup/: sys_init_patch.c nl1000_it_patch.c
  group object
    ./object/: symdefs.o
    ./Output/Objects/: nl1000_a0_patch_at_m3.lib nl1000_a0_patch_pts_m3.lib
  group lib
    ../../../APS_PATCH/middleware/netlink/msg/: msg_patch.c
  group lwip
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/ports/freertos/netif/: wlannetif_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/ports/rom_if/: lwip_jmptbl_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/lwip/src/core/ipv4/: ip4_frag_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/: lwip_helper_patch.c
  group SecurityIPDriver
    ../../../APS_PATCH/driver/chip/securityipdriver/: scrt_patch.c scrt_patch_init.c scrt_cmd.c
  group Drivers
    ../../../APS_PATCH/driver/chip/: peri_patch_init.c
    ../../../APS_PATCH/driver/chip/hal_tmr/: hal_tmr_patch.c
    ../../../APS_PATCH/driver/chip/hal_vic/: hal_vic_patch.c
    ../../../APS_PATCH/driver/chip/hal_system/: hal_system_patch.c
    ../../../APS_PATCH/driver/chip/hal_spi/: hal_flash_patch.c
    ../../../APS_PATCH/driver/chip/hal_dbg_uart/: hal_dbg_uart_patch.c
    ../../../APS_PATCH/driver/chip/hal_uart/: hal_uart_patch.c
    ../../../APS_PATCH/driver/chip/hal_auxadc/: hal_auxadc.c hal_auxadc_cmd.c hal_temperature.c
    ../../../APS_PATCH/driver/chip/hal_wdt/: hal_wdt_patch.c
    ../../../APS_PATCH/driver/chip/hal_pwm/: hal_pwm_patch.c
    ../../../APS_PATCH/driver/chip/hal_tick/: hal_tick_patch.c
    ../../../APS_PATCH/driver/chip/hal_i2c/: hal_i2c_patch.c
  group WPA_Supplicant
    ../../../APS_PATCH/middleware/third_party/wpa_supplicant-0.7.3/wpa_supplicant/: wpas_patch_init.c wpa_cli_patch.c events_netlink_patch.c wpa_supplicant_patch.c supplicant_task_patch.c wpa_at_if.c
    ../../../APS_PATCH/middleware/third_party/wpa_supplicant-0.7.3/src/drivers/: driver_netlink_patch.c
    ../../../APS_PATCH/middleware/third_party/wpa_supplicant-0.7.3/src/rsn_supp/: wpa_patch.c wpa_ie_patch.c
    ../../../APS_PATCH/middleware/third_party/wpa_supplicant-0.7.3/src/utils/: wpa_debug_patch.c
    ../../../APS_PATCH/middleware/third_party/wpa_supplicant-0.7.3/src/common/: wpa_common_patch.c
  group http_client
    ../../../APS_PATCH/middleware/third_party/httpclient/: httpclient.c
  group mw_fim
    ../../../APS_PATCH/middleware/netlink/mw_fim/: mw_fim.c mw_fim_default.c mw_fim_default_group01.c mw_fim_default_group02.c mw_fim_default_group03.c mw_fim_default_group04.c mw_fim_default_group05.c mw_fim_default_group06.c mw_fim_default_group07.c mw_fim_default_group08.c
  group sntp_client
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/lwip/src/apps/sntp/: sntp_client.c
target NL1000_APS_SDK_PTS (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1
  cpu: as above
  output: nl1000_a0_sdk_pts_m3 +hex (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: as above
  c misc: --preinclude=sys_common.h
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
