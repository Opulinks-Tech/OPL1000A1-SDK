# Keil uVision project opl1000_app_m3.uvprojx, settings and files
target OPL1000_APS_App (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: opl1000_app_m3 +hex
  AfterMake: .\opl1000_app_m3.bat $L !L @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __WIFI_AUTO_CONNECT__
  c misc: --preinclude=sys_common.h
  c include: ..\..\FreeRtos\Source\include;..\..\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\driver\CMSIS\Include;..\..\driver\CMSIS\Device\opl1000\Include;..\..\driver\chip;..\..\driver\chip\opl1000\securityipdriver;..\..\driver\chip\opl1000\hal_auxadc;..\..\driver\chip\opl1000\hal_system;..\..\driver\chip\opl1000\hal_patch;..\..\driver\chip\opl1000\hal_uart;..\..\driver\chip\opl1000\hal_spi;..\..\driver\chip\opl1000\hal_vic;..\..\driver\chip\opl1000\hal_dbg_uart;..\..\driver\chip\opl1000\hal_wdt;..\..\driver\chip\opl1000\hal_dma;..\..\driver\chip\opl1000\hal_tmr;..\..\driver\chip\opl1000\hal_tick;..\..\driver\chip\opl1000\hal_pwm;..\..\driver\chip\opl1000\hal_i2c;.\include;..\common;..\..\middleware\netlink;..\..\middleware\netlink\cli;..\..\middleware\netlink\msg;..\..\middleware\netlink\mw_fim;..\..\middleware\netlink\data_flow;..\..\middleware\netlink\wifi_controller_layer;..\..\middleware\netlink\ble_controller_layer\inc;..\..\middleware\netlink\le_stack;..\..\middleware\netlink\at;..\..\middleware\netlink\iperf\inc;..\..\middleware\netlink\controller_task;..\..\middleware\netlink\ps_task;..\..\middleware\netlink\diag_task;..\..\middleware\netlink\wifi_mac;..\..\apps\le_app\pts_app;..\..\apps\le_app\mtc_app;..\..\apps\le_app\cmd_app;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\common;..\..\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eap_common;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eap_peer;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_supp;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_auth;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\radius;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\crypto;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\l2_packet;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\ap;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\wps;..\..\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant\dbus;..\..\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\middleware\third_party\lwip-2.0.3\;..\..\middleware\third_party\tinycrypt\include;..\..\middleware\third_party\mbedtls\include;.\boot_sequence;.\startup;..\..\..\APS_PATCH\project\opl1000\startup;..\..\..\APS_PATCH\project\opl1000\include;..\..\..\APS_PATCH\middleware\netlink\data_flow;..\..\..\APS_PATCH\middleware\netlink\msg;..\..\..\APS_PATCH\middleware\netlink\mw_fim;..\..\..\APS_PATCH\middleware\netlink\mw_ota;..\..\..\APS_PATCH\middleware\netlink\ble_controller_layer\inc;..\..\..\APS_PATCH\middleware\netlink\le_stack\patch;..\..\..\APS_PATCH\middleware\netlink\le_stack\cmd_app;..\..\..\APS_PATCH\middleware\netlink\le_stack\pts_app;..\..\..\APS_PATCH\middleware\netlink\le_stack\mtc_app;..\..\..\APS_PATCH\middleware\netlink\at;..\..\..\APS_PATCH\middleware\netlink\diag_task;..\..\..\APS_PATCH\middleware\netlink\wifi_controller_layer;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\..\APS_PATCH\middleware\netlink\wifi_mac;..\..\..\APS_PATCH\driver\chip\opl1000;..\..\..\APS_PATCH\driver\chip\opl1000\hal_spi;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\..\APS_PATCH\middleware\netlink\wifi_controller_layer\rom_if;..\..\middleware\netlink\wifi_controller_layer\rom_if;..\..\..\APS_PATCH\driver\chip\opl1000\securityipdriver;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\APS_PATCH\middleware\netlink\common\sys_api;..\..\..\APS_PATCH\driver\chip\opl1000\hal_i2c;..\..\..\APS_PATCH\driver\chip\opl1000\hal_pwm;..\..\..\APS_PATCH\driver\chip\opl1000\hal_vic;..\..\..\APS_PATCH\middleware\netlink\cli;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\lwip\src\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  scatter file: .\opl1000_app_m3.sct
  link misc: --datacompressor off --diag_suppress=L6305
  group source
    ../../../APS_PATCH/project/opl1000/startup/: main_patch.c
  group object
    ../../targets/opl1000/object/: symdefs.o
    ../../targets/opl1000/Output/Objects/: opl1000_patch_m3.lib opl1000_sdk_m3.lib opl1000_sdk_at_m3.lib
target OPL1000_APS_App_AT (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1
  cpu: as above
  output: opl1000_app_at_m3 +hex
  AfterMake: .\opl1000_app_m3.bat $L !L @L ..\..\..\
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __WIFI_AUTO_CONNECT__ __AT_CMD_SUPPORT__
  c misc: --preinclude=sys_common.h
  c include: ..\..\FreeRtos\Source\include;..\..\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\driver\CMSIS\Include;..\..\driver\CMSIS\Device\opl1000\Include;..\..\driver\chip;..\..\driver\chip\opl1000\securityipdriver;..\..\driver\chip\opl1000\hal_auxadc;..\..\driver\chip\opl1000\hal_system;..\..\driver\chip\opl1000\hal_patch;..\..\driver\chip\opl1000\hal_uart;..\..\driver\chip\opl1000\hal_spi;..\..\driver\chip\opl1000\hal_vic;..\..\driver\chip\opl1000\hal_dbg_uart;..\..\driver\chip\opl1000\hal_wdt;..\..\driver\chip\opl1000\hal_dma;..\..\driver\chip\opl1000\hal_tmr;..\..\driver\chip\opl1000\hal_tick;..\..\driver\chip\opl1000\hal_pwm;..\..\driver\chip\opl1000\hal_i2c;.\include;..\common;..\..\middleware\netlink;..\..\middleware\netlink\cli;..\..\middleware\netlink\msg;..\..\middleware\netlink\mw_fim;..\..\middleware\netlink\data_flow;..\..\middleware\netlink\wifi_controller_layer;..\..\middleware\netlink\ble_controller_layer\inc;..\..\middleware\netlink\le_stack;..\..\middleware\netlink\at;..\..\middleware\netlink\iperf\inc;..\..\middleware\netlink\controller_task;..\..\middleware\netlink\ps_task;..\..\middleware\netlink\diag_task;..\..\middleware\netlink\wifi_mac;..\..\apps\le_app\pts_app;..\..\apps\le_app\mtc_app;..\..\apps\le_app\cmd_app;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\common;..\..\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eap_common;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eap_peer;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_supp;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_auth;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\radius;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\crypto;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\l2_packet;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\ap;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\wps;..\..\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant\dbus;..\..\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\middleware\third_party\lwip-2.0.3\;..\..\middleware\third_party\tinycrypt\include;..\..\middleware\third_party\mbedtls\include;.\boot_sequence;.\startup;..\..\..\APS_PATCH\project\opl1000\startup;..\..\..\APS_PATCH\project\opl1000\include;..\..\..\APS_PATCH\middleware\netlink\data_flow;..\..\..\APS_PATCH\middleware\netlink\msg;..\..\..\APS_PATCH\middleware\netlink\mw_fim;..\..\..\APS_PATCH\middleware\netlink\mw_ota;..\..\..\APS_PATCH\middleware\netlink\ble_controller_layer\inc;..\..\..\APS_PATCH\middleware\netlink\le_stack\patch;..\..\..\APS_PATCH\middleware\netlink\le_stack\cmd_app;..\..\..\APS_PATCH\middleware\netlink\le_stack\pts_app;..\..\..\APS_PATCH\middleware\netlink\le_stack\mtc_app;..\..\..\APS_PATCH\middleware\netlink\at;..\..\..\APS_PATCH\middleware\netlink\diag_task;..\..\..\APS_PATCH\middleware\netlink\wifi_controller_layer;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\..\APS_PATCH\middleware\netlink\wifi_mac;..\..\..\APS_PATCH\driver\chip\opl1000;..\..\..\APS_PATCH\driver\chip\opl1000\hal_spi;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\..\APS_PATCH\middleware\netlink\wifi_controller_layer\rom_if;..\..\middleware\netlink\wifi_controller_layer\rom_if;..\..\..\APS_PATCH\driver\chip\opl1000\securityipdriver;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\APS_PATCH\middleware\netlink\common\sys_api;..\..\..\APS_PATCH\driver\chip\opl1000\hal_i2c;..\..\..\APS_PATCH\driver\chip\opl1000\hal_pwm;..\..\..\APS_PATCH\driver\chip\opl1000\hal_vic;..\..\..\APS_PATCH\middleware\netlink\cli
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  scatter file: .\opl1000_app_m3.sct
  link misc: --datacompressor off --diag_suppress=L6305
