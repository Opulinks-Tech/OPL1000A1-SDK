# Keil uVision project opl1000_sdk_at_m3.uvprojx, settings and files
target OPL1000_APS_SDK (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: opl1000_sdk_m3 +hex (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __WIFI_AUTO_CONNECT__ MBEDTLS_CONFIG_FILE="<config-opl-mini.h>" __noFULL_MSG_FUNCTION__ __LE_STORE_BONDx__
  c misc: --preinclude=sys_common.h
  c include: ..\..\FreeRtos\Source\include;..\..\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\driver\CMSIS\Include;..\..\driver\CMSIS\Device\opl1000\Include;..\..\driver\chip;..\..\driver\chip\opl1000\securityipdriver;..\..\driver\chip\opl1000\hal_auxadc;..\..\driver\chip\opl1000\hal_system;..\..\driver\chip\opl1000\hal_patch;..\..\driver\chip\opl1000\hal_uart;..\..\driver\chip\opl1000\hal_spi;..\..\driver\chip\opl1000\hal_vic;..\..\driver\chip\opl1000\hal_dbg_uart;..\..\driver\chip\opl1000\hal_wdt;..\..\driver\chip\opl1000\hal_dma;..\..\driver\chip\opl1000\hal_tmr;..\..\driver\chip\opl1000\hal_tick;..\..\driver\chip\opl1000\hal_pwm;..\..\driver\chip\opl1000\hal_i2c;.\include;..\common;..\..\middleware\netlink;..\..\middleware\netlink\cli;..\..\middleware\netlink\msg;..\..\middleware\netlink\mw_fim;..\..\middleware\netlink\data_flow;..\..\middleware\netlink\wifi_controller_layer;..\..\middleware\netlink\ble_controller_layer\inc;..\..\middleware\netlink\le_stack;..\..\middleware\netlink\at;..\..\middleware\netlink\iperf\inc;..\..\middleware\netlink\controller_task;..\..\middleware\netlink\ps_task;..\..\middleware\netlink\diag_task;..\..\middleware\netlink\wifi_mac;..\..\apps\le_app\pts_app;..\..\apps\le_app\mtc_app;..\..\apps\le_app\cmd_app;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\common;..\..\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eap_common;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eap_peer;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_supp;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_auth;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\radius;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\crypto;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\l2_packet;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\ap;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\wps;..\..\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant\dbus;..\..\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\middleware\third_party\lwip-2.0.3\;..\..\middleware\third_party\tinycrypt\include;.\boot_sequence;.\startup;..\..\..\APS_PATCH\project\opl1000\startup;..\..\..\APS_PATCH\project\opl1000\include;..\..\..\APS_PATCH\middleware\netlink\data_flow;..\..\..\APS_PATCH\middleware\netlink\msg;..\..\..\APS_PATCH\middleware\netlink\mw_fim;..\..\..\APS_PATCH\middleware\netlink\mw_ota;..\..\..\APS_PATCH\middleware\netlink\ble_controller_layer\inc;..\..\..\APS_PATCH\middleware\netlink\le_stack\patch;..\..\..\APS_PATCH\middleware\netlink\le_stack\cmd_app;..\..\..\APS_PATCH\middleware\netlink\le_stack\pts_app;..\..\..\APS_PATCH\middleware\netlink\le_stack\mtc_app;..\..\..\APS_PATCH\middleware\netlink\at;..\..\..\APS_PATCH\middleware\netlink\diag_task;..\..\..\APS_PATCH\middleware\netlink\wifi_controller_layer;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\..\APS_PATCH\middleware\netlink\wifi_mac;..\..\..\APS_PATCH\driver\chip\opl1000;..\..\..\APS_PATCH\driver\chip\opl1000\securityipdriver;..\..\..\APS_PATCH\driver\chip\opl1000\hal_spi;..\..\..\APS_PATCH\driver\chip\opl1000\hal_system;..\..\..\APS_PATCH\driver\chip\opl1000\hal_auxadc;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\..\APS_PATCH\middleware\netlink\wifi_controller_layer\rom_if;..\..\middleware\netlink\wifi_controller_layer\rom_if;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\APS_PATCH\middleware\third_party\mbedtls\configs;..\..\..\APS_PATCH\middleware\third_party\mbedtls\port\include;..\..\..\APS_PATCH\middleware\third_party\mbedtls\include;..\..\..\APS_PATCH\middleware\third_party\openssl\include\internal;..\..\..\APS_PATCH\middleware\third_party\openssl\include;..\..\..\APS_PATCH\middleware\third_party\openssl\include\openssl;..\..\..\APS_PATCH\middleware\third_party\openssl\include\platform;..\..\..\APS_PATCH\middleware\netlink\common\sys_api;..\..\..\APS_PATCH\middleware\netlink\common\sys_ctrl;..\..\..\APS_PATCH\middleware\netlink\ps_task;..\..\..\APS_PATCH\middleware\netlink\controller_task;..\..\..\APS_PATCH\FreeRtos\Source\include;..\..\..\APS_PATCH\driver\chip\opl1000\hal_i2c;..\..\..\APS_PATCH\driver\chip\opl1000\hal_pwm;..\..\..\APS_PATCH\driver\chip\opl1000\hal_vic;..\..\..\APS_PATCH\middleware\netlink\cli;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  group source
    ../../../APS_PATCH/project/opl1000/startup/: sys_init_patch.c opl1000_it_patch.c
  group lib
    ../../../APS_PATCH/middleware/netlink/msg/: msg_patch.c
  group mw_fim
    ../../../APS_PATCH/middleware/netlink/mw_fim/: mw_fim_default_patch.c mw_fim_default_group01_patch.c mw_fim_default_group02_patch.c mw_fim_default_group03_patch.c mw_fim_default_group04_patch.c mw_fim_default_group05_patch.c mw_fim_default_group06_patch.c mw_fim_default_group07_patch.c mw_fim_default_group08_patch.c mw_fim_patch.c
  group WPA_Supplicant
    ../../../APS_PATCH/middleware/third_party/wpa_supplicant-0.7.3/wpa_supplicant/: wpa_cli_patch.c wpas_init_patch.c supplicant_task_patch.c events_netlink_patch.c
    ../../../APS_PATCH/middleware/third_party/wpa_supplicant-0.7.3/src/drivers/: driver_netlink_patch.c
    ../../../APS_PATCH/middleware/third_party/wpa_supplicant-0.7.3/src/rsn_supp/: wpa_patch.c
  group cli
    ../../../APS_PATCH/middleware/netlink/cli/: cli_patch.c
  group at
    ../../../APS_PATCH/middleware/netlink/at/: at_cmd_func_patch.c at_cmd_patch.c at_cmd_tcpip_patch.c at_cmd_sys_patch.c at_cmd_app_patch.c at_cmd_msg_ext_patch.c at_cmd_wifi_patch.c at_cmd_common_patch.c at_cmd_data_process_patch.c at_cmd_task_patch.c at_cmd_table_ext.c at_cmd_ble_patch.c at_cmd_rf_patch.c at_cmd_nvm.c
  group driver
    ../../../APS_PATCH/driver/chip/opl1000/: peri_patch_init.c
    ../../../APS_PATCH/driver/chip/opl1000/hal_spi/: hal_flash_patch.c hal_spi_patch.c
    ../../../APS_PATCH/driver/chip/opl1000/hal_system/: hal_system_patch.c hal_pin.c hal_gpio.c
    ../../../APS_PATCH/driver/chip/opl1000/hal_auxadc/: hal_auxadc_patch.c
    ../../../APS_PATCH/driver/chip/opl1000/hal_i2c/: hal_i2c_patch.c
    ../../../APS_PATCH/driver/chip/opl1000/hal_pwm/: hal_pwm_patch.c
    ../../../APS_PATCH/driver/chip/opl1000/hal_vic/: hal_vic_patch.c
  group mw_ota
    ../../../APS_PATCH/middleware/netlink/mw_ota/: mw_ota.c
  group SecurityIPDriver
    ../../../APS_PATCH/driver/chip/opl1000/securityipdriver/: scrt_cmd_patch.c scrt_patch.c
  group lwip
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/ports/freertos/netif/: wlannetif_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/ports/rom_if/: lwip_jmptbl_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/lwip/src/api/: sockets_patch.c tcpip_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/: network_config_patch.c lwip_cli_patch.c lwip_helper_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/ports/rom_if/api/: tcpip_if_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/ports/freertos/: sys_arch_freertos_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/lwip/src/core/ipv4/: dhcp_patch.c etharp_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/lwip/src/core/: timeouts_patch.c tcp_patch.c
  group http_client
    ../../../APS_PATCH/middleware/third_party/httpclient/: httpclient.c
  group mbedtls
    ../../../APS_PATCH/middleware/third_party/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
    ../../../APS_PATCH/middleware/third_party/mbedtls/port/: net_sockets.c sha1_alt.c sha256_alt.c
  group openssl
    ../../../APS_PATCH/middleware/third_party/openssl/library/: ssl_cert.c ssl_lib.c ssl_methods.c ssl_pkey.c ssl_stack.c ssl_x509.c
    ../../../APS_PATCH/middleware/third_party/openssl/platform/: ssl_pm.c ssl_port.c
  group common
    ../../../APS_PATCH/middleware/netlink/common/sys_api/: sys_common_api.c
    ../../../APS_PATCH/middleware/netlink/common/sys_ctrl/: sys_common_ctrl.c
  group ble_host
    ../../../APS_PATCH/middleware/netlink/ble_host/: ble_host_patch_init.c
target OPL1000_APS_SDK_AT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: as above
  output: opl1000_sdk_at_m3 +hex (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __WIFI_AUTO_CONNECT__ MBEDTLS_CONFIG_FILE="<config-opl-mini.h>" __AT_CMD_SUPPORT__ __noATCWLAP_SCAN_HISTORY_EN__  __FULL_MSG_FUNCTION__ __BLE_CMD_PTS__ __LE_STORE_BONDx__
  c misc: --preinclude=sys_common.h
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
