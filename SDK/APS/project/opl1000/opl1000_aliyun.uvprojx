# Keil uVision project opl1000_aliyun.uvprojx, settings and files
target opl1000_aliyun (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.1
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: opl1000_aliyun +hex (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __WIFI_AUTO_CONNECT__ MBEDTLS_CONFIG_FILE="<config-opl-mini.h>" __noFULL_MSG_FUNCTION__ __LE_STORE_BONDx__
  c misc: --preinclude=sys_common.h
  c include: ..\..\FreeRtos\Source\include;..\..\FreeRtos\Source\portable\Keil\ARM_CM3;..\..\driver\CMSIS\Include;..\..\driver\CMSIS\Device\opl1000\Include;..\..\driver\chip;..\..\driver\chip\opl1000\securityipdriver;..\..\driver\chip\opl1000\hal_auxadc;..\..\driver\chip\opl1000\hal_system;..\..\driver\chip\opl1000\hal_patch;..\..\driver\chip\opl1000\hal_uart;..\..\driver\chip\opl1000\hal_spi;..\..\driver\chip\opl1000\hal_vic;..\..\driver\chip\opl1000\hal_dbg_uart;..\..\driver\chip\opl1000\hal_wdt;..\..\driver\chip\opl1000\hal_dma;..\..\driver\chip\opl1000\hal_tmr;..\..\driver\chip\opl1000\hal_tick;..\..\driver\chip\opl1000\hal_pwm;..\..\driver\chip\opl1000\hal_i2c;.\include;..\common;..\..\middleware\netlink;..\..\middleware\netlink\cli;..\..\middleware\netlink\msg;..\..\middleware\netlink\mw_fim;..\..\middleware\netlink\data_flow;..\..\middleware\netlink\wifi_controller_layer;..\..\middleware\netlink\ble_controller_layer\inc;..\..\middleware\netlink\le_stack;..\..\middleware\netlink\at;..\..\middleware\netlink\iperf\inc;..\..\middleware\netlink\controller_task;..\..\middleware\netlink\ps_task;..\..\middleware\netlink\diag_task;..\..\middleware\netlink\wifi_mac;..\..\apps\le_app\pts_app;..\..\apps\le_app\mtc_app;..\..\apps\le_app\cmd_app;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\common;..\..\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eap_common;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eap_peer;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_supp;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\eapol_auth;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\radius;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\crypto;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\l2_packet;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\ap;..\..\middleware\third_party\wpa_supplicant-0.7.3\src\wps;..\..\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant\dbus;..\..\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\middleware\third_party\lwip-2.0.3\;..\..\middleware\third_party\tinycrypt\include;.\boot_sequence;.\startup;..\..\..\APS_PATCH\project\opl1000\startup;..\..\..\APS_PATCH\project\opl1000\include;..\..\..\APS_PATCH\middleware\netlink\data_flow;..\..\..\APS_PATCH\middleware\netlink\msg;..\..\..\APS_PATCH\middleware\netlink\mw_fim;..\..\..\APS_PATCH\middleware\netlink\mw_ota;..\..\..\APS_PATCH\middleware\netlink\ble_controller_layer\inc;..\..\..\APS_PATCH\middleware\netlink\le_stack\patch;..\..\..\APS_PATCH\middleware\netlink\le_stack\cmd_app;..\..\..\APS_PATCH\middleware\netlink\le_stack\pts_app;..\..\..\APS_PATCH\middleware\netlink\le_stack\mtc_app;..\..\..\APS_PATCH\middleware\netlink\at;..\..\..\APS_PATCH\middleware\netlink\diag_task;..\..\..\APS_PATCH\middleware\netlink\wifi_controller_layer;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\wpa_supplicant;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\utils;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\rsn_supp;..\..\..\APS_PATCH\middleware\netlink\wifi_mac;..\..\..\APS_PATCH\driver\chip\opl1000;..\..\..\APS_PATCH\driver\chip\opl1000\securityipdriver;..\..\..\APS_PATCH\driver\chip\opl1000\hal_spi;..\..\..\APS_PATCH\driver\chip\opl1000\hal_system;..\..\..\APS_PATCH\driver\chip\opl1000\hal_auxadc;..\..\..\APS_PATCH\middleware\third_party\wpa_supplicant-0.7.3\src\drivers;..\..\..\APS_PATCH\middleware\netlink\wifi_controller_layer\rom_if;..\..\middleware\netlink\wifi_controller_layer\rom_if;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\APS_PATCH\middleware\third_party\mbedtls\configs;..\..\..\APS_PATCH\middleware\third_party\mbedtls\port\include;..\..\..\APS_PATCH\middleware\third_party\mbedtls\include;..\..\..\APS_PATCH\middleware\third_party\openssl\include\internal;..\..\..\APS_PATCH\middleware\third_party\openssl\include;..\..\..\APS_PATCH\middleware\third_party\openssl\include\openssl;..\..\..\APS_PATCH\middleware\third_party\openssl\include\platform;..\..\..\APS_PATCH\middleware\netlink\common\sys_api;..\..\..\APS_PATCH\middleware\netlink\common\sys_ctrl;..\..\..\APS_PATCH\middleware\netlink\ps_task;..\..\..\APS_PATCH\middleware\netlink\controller_task;..\..\..\APS_PATCH\FreeRtos\Source\include;..\..\..\APS_PATCH\driver\chip\opl1000\hal_i2c;..\..\..\APS_PATCH\driver\chip\opl1000\hal_pwm;..\..\..\APS_PATCH\driver\chip\opl1000\hal_vic;..\..\..\APS_PATCH\middleware\netlink\cli;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3;..\..\..\APS_PATCH\middleware\third_party\aliyun\src\dev_sign;..\..\..\APS_PATCH\middleware\third_party\aliyun\src\infra;..\..\..\APS_PATCH\middleware\third_party\aliyun\src\mqtt;..\..\..\APS_PATCH\middleware\third_party\aliyun\src\mqtt\impl;..\..\..\APS_PATCH\middleware\third_party\aliyun\wrappers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0xc0000
  memory RVCT9: RAM 0x400000 size 0x50000
  group ali_src_dev_sign
    ../../../APS_PATCH/middleware/third_party/aliyun/src/dev_sign/: dev_sign_mqtt.c
  group ali_src_infra
    ../../../APS_PATCH/middleware/third_party/aliyun/src/infra/: infra_compat.c infra_defs.c infra_net.c infra_report.c infra_sha256.c infra_string.c infra_timer.c
  group ali_src_mqtt
    ../../../APS_PATCH/middleware/third_party/aliyun/src/mqtt/: mqtt_api.c
  group al_src_mqtt_impl
    ../../../APS_PATCH/middleware/third_party/aliyun/src/mqtt/impl/: iotx_mqtt_client.c MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group ali_wrappers_os_freertos
    ../../../APS_PATCH/middleware/third_party/aliyun/wrappers/os/freertos/: HAL_OS_Freertos.c
